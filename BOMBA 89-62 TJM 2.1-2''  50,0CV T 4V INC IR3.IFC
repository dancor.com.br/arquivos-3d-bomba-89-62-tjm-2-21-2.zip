Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: W:\PRODUTOS\ALTOQI\IFCs . STP\BOMBA 89-62 TJM 2.1-2'' 50,0CV T 4V INC IR3.IFC
Time: 2026-06-08T14:46:02+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
